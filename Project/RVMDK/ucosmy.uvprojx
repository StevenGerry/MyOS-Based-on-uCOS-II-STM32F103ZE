# Keil uVision project ucosmy.uvprojx, settings and files
target UCOS_MyOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOS_MyOS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\User;..\..\Micrium\Software\uCOS-II\Source;..\..\APP;..\..\Micrium\Software\uCOS-II\Ports\arm-cortex-m3\Generic\IAR;.\RTE\Device\STM32F103ZE;..\..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../User/: main.c stm32f10x_it.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOS/SRC
    ../../Micrium/Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOS/PORT
    ../../Micrium/Software/uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group APP
    ../../APP/: app.c app_cfg.h includes.h os_cfg.h
  group BSP
    ../../User/bsp/: oled.c oledfont.c esp8266.c user_exti.c led.c user_ili9341_lcd.c ov7670.c sccb.c ds18b20.c user_usart.c mpu6050.C
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:GPIO 1.3, Device:Startup 1.0.0
